# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: pacman.c
software components: CMSIS Driver:SPI:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Device:Startup 2.5.0
